# Keil uVision project enel_452.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u6)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: enel_452
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: cli.c cli.h clock.c clock.h main.c pin.c pin.h task.c tim.c tim.h uart.c uart.h util.c util.h tasks.c tasks.h interrupt.c interrupt.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 1.0.0
