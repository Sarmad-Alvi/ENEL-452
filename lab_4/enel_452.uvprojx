# Keil uVision project enel_452.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u6)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: enel_452
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c clock.c clock.h pin.c pin.h util.c util.h uart.c uart.h cli.c cli.h tim.c tim.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
